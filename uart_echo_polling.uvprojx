# Keil uVision project uart_echo_polling.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: uart_echo_polling +hex
  AfterMake: fromelf.exe --bin "#L" -o "$P\Debug\Objects\bin\@L.bin"
  c flags: Optim=1 wLevel=2
  c define: __SRAMBOOT__
  c misc: --gnu
  c include: ..\..\..\Drivers\CMSIS\include;..\..\..\Drivers\MS500\Device\inc;..\..\..\Drivers\MS500\Drivers\inc;..\..\..\Drivers\MS500\Security\inc;..\..\..\Drivers\MS500\Utils\inc;..\uart_echo_polling
  memory RVCT4: ROM 0x20000000 size 0xc800
  memory RVCT9: RAM 0x2000c800 size 0x3800
  scatter file: .\ms500SRAM.sct
  link misc: --datacompressor off --no_strict_wchar_size
  group Device
    ../../../Drivers/MS500/Device/src/: startup_MS500.c system_MS500.c
  group Drivers
    ../../../Drivers/MS500/Drivers/src/: hal_clock.c hal_delay.c hal_dma.c hal_flash.c hal_gpio.c hal_i2c.c hal_irq.c hal_pinmap.c hal_pmu.c hal_rtc.c hal_sdioh.c hal_sdios.c hal_spi.c hal_syscon.c hal_tmr.c hal_uart.c hal_wwdt.c
  group Security
    ../../../Drivers/MS500/Security/src/: hal_pka.c hal_spacc.c hal_trng.c
  group Utils
    ../../../Drivers/MS500/Utils/src/: util_printf.c
  group Example
    ./: main.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: uart_echo_polling +hex
  AfterMake: fromelf.exe --bin "#L" -o "$P\Release\Objects\bin\@L.bin"
  c flags: Optim=3 wLevel=1
  c misc: --gnu
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\ms500.sct
  link misc: --datacompressor off --no_strict_wchar_size
